# IAR project HOOK_BOOT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS; ..\..\User; ..\..\..\ThirtyParty\Common\inc; ..\..\..\ThirtyParty\ymodem; ..\..\Configs\inc; ..\..\Bsp\inc; ..\..\Iap\inc; ..\..\Shell\inc; ..\..\..\ThirtyParty\cmd-parser-master; ..\..\Configs\inc; ..\..\Drv\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HOOK_BOOT.bin
  ILINK.IlinkOutputFile: HOOK_BOOT.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f405xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\arm; ..\..\User\control; ..\..\User\driver; ..\..\User\motor; ..\..\User\test; ..
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: STM32F41x.out
  group (top)
    ../: 硬件配置.txt
  group Bsp
    ../../Bsp/: bsp.c bsp_flash.c bsp_misc.c bsp_usart.c
  group Cmd
    ../../../ThirtyParty/cmd-parser-master/: cmd.c
  group Cmsis
    ../../../Libraries/CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Common
    ../../../ThirtyParty/Common/: common.c common_crc.c ringfifo.c
  group Drv
    ../../Drv/: gpio.c
  group Iap
    ../../Iap/: iap.c
  group Library
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Param
    ../../Configs/: conf_param.c
  group Shell
    ../../Shell/: shell_init.c
  group User
    ../../User/: main.c stm32f4xx_it.c
  group Ymodem
    ../../../ThirtyParty/ymodem/: ymodem.c ymodem_common.c ymodem_port.c
